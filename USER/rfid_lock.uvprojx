# Keil uVision project rfid_lock.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: rfid_lock +hex
  c flags: Optim=1 uC99=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER,CP2532_INT_ENABLE
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\SPI;..\HARDWARE\FLASH;..\HARDWARE\RFID;.\dev;..\SYSTEM;..\HARDWARE\STMFLASH;..\HARDWARE\TIMER;..\UCOSII\CONFIG;..\UCOSII\CORE;..\UCOSII\PORT;..\task;..\module;..\HARDWARE
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.cpp platform.cpp param.c stm32f10x_it.c system_stm32f10x.c common.cpp
  group TASK
    ../task/: can_protocol_task.cpp led_task.cpp lock_task.cpp
  group MODULE
    ../module/: can_fifo.c
  group DEV
    ./dev/: beeper.cpp lock.cpp
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group HARDWARE
    ../HARDWARE/SPI/: SPI.cpp
    ../HARDWARE/LED/: led.cpp
    ../HARDWARE/TIMER/: timer.cpp
    ../HARDWARE/: can.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_spi.c stm32f10x_can.c stm32f10x_exti.c stm32f10x_flash.c
  group UCOSII-CORE
    ../UCOSII/CORE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group UCOSII-PORT
    ../UCOSII/PORT/: os_cpu_c.c os_dbg.c os_cpu_a.asm
  group UCOSII-CONFIG
    ../UCOSII/CONFIG/: includes.h os_cfg.h
